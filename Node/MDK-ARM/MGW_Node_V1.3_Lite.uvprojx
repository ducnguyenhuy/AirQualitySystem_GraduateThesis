# Keil uVision project MGW_Node_V1.3_Lite.uvprojx, settings and files
target MGW_Node_V1.3_Lite (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L072RBTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: MGW_Node_V1.3_Lite +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L072xx
  c include: ../Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc;    ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;    ../Drivers/CMSIS/Include;    ..\User_Code\Apps;    ..\User_Code\Base;    ..\User_Code\Utilities\Uart_Debug;    ..\User_Code\Drivers\Devices\Sx127x;    ..\User_Code\Drivers\Devices\InterBoard;    ..\User_Code\Services\LoRaMAC;    ..\User_Code\Services\LoRa
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l072xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c rng.c spi.c stm32l0xx_it.c stm32l0xx_hal_msp.c stm32l0xx_hal_timebase_tim.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rng.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group User_Code/Apps
    ../User_Code/Apps/: app.c
  group User_Code/Uart_Debug
    ../User_Code/Utilities/Uart_Debug/: Uart_Debug.c
  group User_Code/sx127x
    ../User_Code/Drivers/Devices/Sx127x/: sx127x.c
    ../User_Code/Drivers/Devices/Sx127x/cfg/: sx127x_cfg.c
  group User_Code/LoRa_Service
    ../User_Code/Services/LoRa/: LoRa_Services.c
  group User_Code/LoRaMAC
    ../User_Code/Services/LoRaMAC/: LoRaMac_Node.c
    ../User_Code/Services/LoRaMAC/cfg/: LoRaMac_Node_Cfg.c
software components: CMSIS:CORE 4.3.0
